/*************************************************************************

  This file is part of the ParaNut project.

  Copyright (C) 2022 Nico Borgsmüller <nico.borgsmueller@hs-augsburg.de>
      Hochschule Augsburg, University of Applied Sciences

  Redistribution and use in source and binary forms, with or without modification,
  are permitted provided that the following conditions are met:

  1. Redistributions of source code must retain the above copyright notice, this 
     list of conditions and the following disclaimer.

  2. Redistributions in binary form must reproduce the above copyright notice,
     this list of conditions and the following disclaimer in the documentation and/or
     other materials provided with the distribution.

  THIS SOFTWARE IS PROVIDED BY THE COPYRIGHT HOLDERS AND CONTRIBUTORS "AS IS" AND 
  ANY EXPRESS OR IMPLIED WARRANTIES, INCLUDING, BUT NOT LIMITED TO, THE IMPLIED 
  WARRANTIES OF MERCHANTABILITY AND FITNESS FOR A PARTICULAR PURPOSE ARE 
  DISCLAIMED. IN NO EVENT SHALL THE COPYRIGHT HOLDER OR CONTRIBUTORS BE LIABLE FOR
  ANY DIRECT, INDIRECT, INCIDENTAL, SPECIAL, EXEMPLARY, OR CONSEQUENTIAL DAMAGES 
  (INCLUDING, BUT NOT LIMITED TO, PROCUREMENT OF SUBSTITUTE GOODS OR SERVICES; 
  LOSS OF USE, DATA, OR PROFITS; OR BUSINESS INTERRUPTION) HOWEVER CAUSED AND ON 
  ANY THEORY OF LIABILITY, WHETHER IN CONTRACT, STRICT LIABILITY, OR TORT 
  (INCLUDING NEGLIGENCE OR OTHERWISE) ARISING IN ANY WAY OUT OF THE USE OF THIS 
  SOFTWARE, EVEN IF ADVISED OF THE POSSIBILITY OF SUCH DAMAGE.

 *************************************************************************/

/dts-v1/;

/ {
	#address-cells = <1>;
	#size-cells = <1>;

	compatible = "hsa-ees,paranut";

	chosen {
		stdout-path = "/serial0";
		bootargs = "console=hvc0 earlycon=sbi";
	};

	cpus {
		timebase-frequency = <{TIMER_FREQ}>;
		#address-cells = <1>;
		#size-cells = <0>;
		cpu@0 {
			compatible = "hsa-ees,paranut", "riscv";
			device_type = "cpu";
			reg = <0>;
			riscv,isa = "rv32im";
			mmu-type = "riscv,sv32";
			cpu0_intc: interrupt-controller {
				#interrupt-cells = <1>;
				compatible = "riscv,cpu-intc";
				interrupt-controller;
			};
		};
	};

	timer@{MTIME_ADDR} {
		compatible = "riscv,aclint-mtimer";
		#address-cells = <2>;
		#size-cells = <2>;
		reg = <0x{MTIME_ADDR} 0x8 0x{MTIMECMP_ADDR} 0x8>; // Addresses of mtime and mtimecmp
		interrupts-extended = <&cpu0_intc 7>;
	};

	memory@{MEM_ADDR} {
		device_type = "memory";
		reg = <0x{MEM_ADDR} 0x{MEM_SIZE}>;
	};

	serial0 {
		compatible = "hsa-ees,pn-tohost";
	};
};
